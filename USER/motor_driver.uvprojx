# Keil uVision project motor_driver.uvprojx, settings and files
target driver (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor_driver +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYS\delay;..\SYS\sys;..\SYS\usart;..\LIB\ins;..\USER;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c system_stm32f10x.c stm32f10x_it.c YTCH_Driver.c
  group sys
    ../SYS/delay/: delay.c
    ../SYS/sys/: sys.c
    ../SYS/usart/: usart.c
  group hardware
    ../HARDWARE/: can.c timer2.c led.c order.c usb_communication.c gps.c
    ./: transfer.c usart3.c
  group lib
    ../LIB/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
